# Repository tuchimur/eagle

## EAGLE design projects/polyatom_psu/psu1.brd

Parts:
BR1, BR2: GBU4J; SIL4
C1, C11: 1000u; E5-13
C2: 0.22u; C1206
C3, C6, C7, C8, C9, C10, C16, C17, C18, C19: 100n; C1206
C4, C5, C14, C15: CPOL-USTT2D5; TT2D5
C12: 2.2u; C1206
C13: 1u; C1206
D1, D2: HLMP6
D3, D4: 1N4004; DO41-10
GND: 3,81/1,1
R1, R3: 680; 0207/10
U$1: LM7815; TO-220
U$3, U$4, U$5: BANANA
U$6: LM7915; TO-220
U$8: TERMINALBLOCK; TERMINALBLOKC
V2: 3,81/1,1

Connections:
+15V: C3.1, C4.+, C5.+, C6.1, C7.1, C8.1, C9.1, C10.1, D3.C, R1.2, U$1.P$3, U$3.P$1
-15V: C13.2, C14.-, C15.-, C16.2, C17.2, C18.2, C19.2, D1.K, D4.A, U$5.P$1, U$6.P$3
GND: BR1.P$4, BR2.P$1, C1.-, C2.2, C3.2, C4.-, C5.-, C6.2, C7.2, C8.2, C9.2, C10.2, C11.+, C12.1, C13.1, C14.+, C15.+, C16.1, C17.1, C18.1, C19.1, D2.K, D3.A, D4.C, GND.1, R3.2, U$1.P$2, U$4.P$1, U$6.P$1, U$8.P$3
unnamed: D2.A, R1.1
unnamed: D1.A, R3.1
unnamed: BR1.P$2, U$8.P$1
unnamed: BR1.P$3, U$8.P$2
unnamed: BR2.P$2, U$8.P$5
unnamed: BR2.P$3, U$8.P$4
NEG: BR2.P$4, C11.-, C12.2, U$6.P$2
POS: BR1.P$1, C1.+, C2.1, U$1.P$1, V2.1

Notes on the sheet:
Polyatom Power Supply
Specifications: +/- 15V - 0.5A (closer to like 100mA maybe) +5V - (probably like 0.5A tops but heavily doubt)

Board: 2 copper layers, 49.5 x 97.5 mm, 35 parts (0 on the bottom side), 11 nets.

## EAGLE design projects/EEG_449_10_30_18/EEG.brd

Parts:
C1: 10n; C025-040X050
C2, C3: 1u; C025-040X050
C4: 0.47u; C025-040X050
C5: 0.1u; C025-040X050
D1: HLMP6
G1: AB9V
INPUT: R-US_0207/12; 0207/12
Q1: 2N3906; TO92
R1: 28k; 0207/5V
R2: 110k; 0207/5V
R3: 98k; 0207/5V
R4, R17: 200; 0207/5V
R5: 6.2k; 0207/5V
R6: 9.1k; 0207/5V
R7, R8, R11, R12, R15, R16, R20, R21: 100k; 0207/5V
R9: 91k; 0207/5V
R10, R13, R14: 10k; 0207/5V
U1, U2: LM348_D_14; D14
U3: LM239_D_14; D14

Connections:
2: R2.2, R3.2, U2.5 (2IN+)
GND: C2.2, C4.2, C5.2, G1.-, Q1.1 (C), R8.1, U1.11 (VCC-), U2.11 (VCC-), U3.12 (GND)
unnamed: C3.2, R5.2, R6.1
unnamed: C4.1, R5.1, R9.1, U2.12 (4IN+), U3.7 (1IN+)
unnamed: R7.1, R8.2, U1.2 (1IN-)
unnamed: R12.1, R14.2, R17.1, U1.9 (3IN-)
unnamed: INPUT.2, R20.2, U1.12 (4IN+)
unnamed: INPUT.1, R21.1, U1.10 (3IN+)
unnamed: R11.1, R13.2, R17.2, U1.13 (4IN-)
unnamed: R12.2, U1.8 (3OUT)
unnamed: R14.1, R16.2, U2.3 (1IN+)
unnamed: R11.2, U1.14 (4OUT)
unnamed: R6.2, R13.1, R15.1, R15.2, U2.1 (1OUT), U2.2 (1IN-)
unnamed: R10.2, R16.1, R20.1, R21.2, U1.1 (1OUT), U1.3 (1IN+), U2.6 (2IN-), U2.10 (3IN+)
unnamed: C3.1, U2.14 (4OUT)
unnamed: R1.2, R2.1, U2.7 (2OUT)
unnamed: R9.2, R10.1, U2.13 (4IN-)
unnamed: C1.2, R1.1, U2.9 (3IN-)
unnamed: C1.1, R3.1, U2.8 (3OUT), U3.6 (1IN-)
unnamed: C5.1, G1.+, R4.1, R7.2, U1.4 (VCC+), U2.4 (VCC+), U3.3 (VCC)
unnamed: Q1.2 (B), U3.1 (1OUT)
unnamed: D1.K, Q1.3 (E)
unnamed: D1.A, R4.2

Board: 2 copper layers, 68.2 x 77.5 mm, 31 parts (0 on the bottom side), 23 nets.

## Commit log

2019-05-02 second commit
2019-05-08 completed psu
2019-05-09 added top and bottom pour, caps renamed
2019-05-10 added text to the top and bottom of board
